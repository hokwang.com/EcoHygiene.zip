Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EcoHygiene¥~´ß.IFC
Time: 2022-01-04T06:20:12
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EcoHygiene¥~´ß_A0_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: EcoHygiene¥~´ß©T©w¤ù-§ï2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
